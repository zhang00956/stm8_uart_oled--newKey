# IAR project demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152K6 STM8L152K6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x120
  General.GenHeapSize: 0x258
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; STM8L15x_StdPeriph_Driver\inc; APP; BSP; HARDDRIVER\Led; HARDDRIVER\adc; HARDDRIVER\Lcd; HARDDRIVER\delay; HARDDRIVER\rtc; HARDDRIVER\exit; HARDDRIVER\dma; HARDDRIVER\uart; stm8_lora\rf
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: lnkstm8l152k6.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group APP
    APP/: beep.c key.c LCD_ZK.c LCD_ZK.h low_power.c main.c queue.c stm8l15x_it.c timer.c
    BSP/: mini-printf.c sysclk.c
    HARDDRIVER/uart/: uart.c
  group STM8L15x_StdPeriph_Driver
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
